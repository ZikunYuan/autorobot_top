# Keil uVision project EXTI.uvprojx, settings and files
target EXTI (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EXIT +hex
  c flags: Optim=1 uC99=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\FWLIB\inc;..\HARDWARE\ENCODER;..\CONTROL;..\HARDWARE\filter;..\HARDWARE\MOTOR;..\HARDWARE\IIC;..\HARDWARE\MPU6050;..\HARDWARE\DMP;..\HARDWARE\OLED;..\HARDWARE\show;..\HARDWARE\ANO_DT;..\HARDWARE\FLASH;..\HARDWARE\HMC5883L;..\HARDWARE\Time;..\CONTROL\Task_Loop;..\SYSTEM\SysTick;..\HARDWARE\Sensor_Param;..\CONTROL\IMU;..\HARDWARE\My_math;..\HARDWARE\AK8975;..\HARDWARE\Stepper;..\HARDWARE\KS103;..\HARDWARE\Motor_Drive;..\HARDWARE\CAN;..\HARDWARE\Sterring;..\HARDWARE\Relay;..\HARDWARE\usart3;..\USER;..\HARDWARE\Auto_math;..\HARDWARE\EXTI;..\HARDWARE\RoboModule;..\HARDWARE\usart5
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c main_assistant.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/FLASH/: stmflash.c
    ../HARDWARE/Time/: Time.c
    ../HARDWARE/My_math/: mymath.c
    ../HARDWARE/Stepper/: Stepper.c
    ../HARDWARE/Motor_Drive/: epos_N.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/Relay/: Relay.c
    ../HARDWARE/usart3/: usart3.c
    ../HARDWARE/Auto_math/: auto_math.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/RoboModule/: RoboModule_can2.c
    ../HARDWARE/usart5/: usart5.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/SysTick/: SysTick.c
    ../SYSTEM/delay/: delay.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_wwdg.c
  group README
    ../: readme.txt
  group CONTROL
    ../HARDWARE/ANO_DT/: ANO_DT.c
